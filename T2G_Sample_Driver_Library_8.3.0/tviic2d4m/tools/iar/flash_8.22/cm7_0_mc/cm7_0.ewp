# IAR project cm7_0.ewp, settings and files
configuration rev_a (ARM, debug)
  General.OGChipSelectEditMenu: CYT3DL_M7 Infineon CYT3DL_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_a; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_a; ..\..\..\..\hdr\rev_a\ip; ..\..\..\..\hdr\rev_a\mcureg; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\interrupts\rev_a; ..\..\..\..\src\mw; ..\..\..\..\src\system\rev_a
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cm7_0.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_$LINK_LOCATION$_=0
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviic2d4m.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\tviic2d4m\src\drivers\crypto\libs\libcrypto_client_cm7_0_iar.a; ..\libmw\rev_a\cm7\libmw.a; ..\libsdl\rev_a\cm7\libsdl.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rev_b (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_b; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_b; ..\..\..\..\hdr\rev_b\ip; ..\..\..\..\hdr\rev_b\mcureg; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\interrupts\rev_b; ..\..\..\..\src\mw; ..\..\..\..\src\system\rev_b
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\tviic2d4m\src\drivers\crypto\libs\libcrypto_client_cm7_0_iar.a; ..\libmw\rev_b\cm7\libmw.a; ..\libsdl\rev_b\cm7\libsdl.a
configuration rev_c (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_c; CY_216TEQFP_EVK_rev_a; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_c; ..\..\..\..\hdr\rev_c\ip; ..\..\..\..\hdr\rev_c\mcureg; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\interrupts\rev_c; ..\..\..\..\src\mw; ..\..\..\..\src\system\rev_c
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\tviic2d4m\src\drivers\crypto\libs\libcrypto_client_cm7_0_iar.a; ..\libmw\rev_c\cm7\libmw.a; ..\libsdl\rev_c\cm7\libsdl.a
configuration lite_kit (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLBBHS; CY_USE_PSVP=0; CY_MCU_rev_c; CY_272BGA_EVKLITE_rev_a; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\tviic2d4m\src\drivers\crypto\libs\libcrypto_client_cm7_0_iar.a; ..\libmw\lite_kit\cm7\libmw.a; ..\libsdl\lite_kit\cm7\libsdl.a
  group hdr
    ../../../../../common/hdr/: cy_project.h
  group hdr/cmsis/include
    ../../../../../common/hdr/cmsis/include/: cmsis_compiler.h core_cm0plus.h
  group hdr/rev_a
    ../../../../hdr/rev_a/: bb_bsp_tviic2d4m.h cy_device_headers.h cyt3dl_config.h
  group hdr/rev_a/ip
    ../../../../hdr/rev_a/ip/: cyip_axi_dmac.h cyip_backup_v3.h cyip_canfd.h cyip_cpuss.h cyip_crypto.h cyip_cxpi.h cyip_dac.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v5.h cyip_headers.h cyip_hsiom_v5.h cyip_ipc.h cyip_lin.h cyip_mixer.h cyip_pass.h cyip_pd.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_pwm.h cyip_scb_v2.h cyip_sflash_v2.h cyip_sg.h cyip_smartio_v5.h cyip_smif.h cyip_srss_v3.h cyip_tcpwm_v2.h cyip_tdm.h cyip_videoss.h
  group hdr/rev_b
    ../../../../hdr/rev_b/: bb_bsp_tviic2d4m.h cy_device_headers.h cyt3dl_config.h
  group hdr/rev_b/ip
    ../../../../hdr/rev_b/ip/: cyip_axi_dmac.h cyip_backup_v3.h cyip_canfd.h cyip_coredefines.h cyip_cpuss.h cyip_crypto.h cyip_cxpi.h cyip_dac.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth_v2.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v5.h cyip_headers.h cyip_hsiom_v5.h cyip_ipc.h cyip_lin.h cyip_mixer.h cyip_pass.h cyip_pd.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_pwm.h cyip_scb_v2.h cyip_sflash_v2.h cyip_sg.h cyip_smartio_v5.h cyip_smif_v3.h cyip_srss_v3.h cyip_tcpwm_v2.h cyip_tdm.h cyip_videoss.h
  group hdr/rev_c
    ../../../../hdr/rev_c/: bb_bsp_tviic2d4m.h cy_device_headers.h cyt3dl_config.h
  group hdr/rev_c/ip
    ../../../../hdr/rev_c/ip/: cyip_axi_dmac.h cyip_backup_v3.h cyip_canfd.h cyip_coredefines.h cyip_cpuss.h cyip_crypto.h cyip_cxpi.h cyip_dac.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth_v2.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v5.h cyip_headers.h cyip_hsiom_v5.h cyip_ipc.h cyip_lin.h cyip_mixer.h cyip_pass.h cyip_pd.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_pwm.h cyip_scb_v2.h cyip_sflash_v2.h cyip_sg.h cyip_smartio_v5.h cyip_smif_v3.h cyip_srss_v3.h cyip_tcpwm_v2.h cyip_tdm.h cyip_videoss.h
  group src
    ../../../../src/: main_cm7_0.c
  group src/interrupts/rev_a
    ../../../../src/interrupts/rev_a/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h
  group src/interrupts/rev_b
    ../../../../src/interrupts/rev_b/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
  group src/interrupts/rev_c
    ../../../../src/interrupts/rev_c/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
  group src/startup
    ../../../../../common/src/startup/: startup.c startup_customize.h
    ../../../../../common/src/startup/iar/: startup_cm7.s
  group src/system/rev_a
    ../../../../src/system/rev_a/: system_cyt3dl.h system_tviic2d4m_cm7.c
  group src/system/rev_b
    ../../../../src/system/rev_b/: system_cyt3dl.h system_tviic2d4m_cm7.c
  group src/system/rev_c
    ../../../../src/system/rev_c/: system_cyt3dl.h system_tviic2d4m_cm7.c
