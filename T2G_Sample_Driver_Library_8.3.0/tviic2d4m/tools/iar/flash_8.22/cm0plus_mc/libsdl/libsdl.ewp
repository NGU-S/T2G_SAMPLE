# IAR project libsdl.ewp, settings and files
configuration rev_a (ARM, debug)
  General.OGChipSelectEditMenu: CYT3DL_M0+ Infineon CYT3DL_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_a
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\common\hdr; ..\..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\..\common\src\drivers; ..\..\..\..\..\..\common\src\mw; ..\..\..\..\..\hdr\rev_a; ..\..\..\..\..\hdr\rev_a\ip; ..\..\..\..\..\hdr\rev_a\mcureg; ..\..\..\..\..\src; ..\..\..\..\..\src\drivers; ..\..\..\..\..\src\interrupts\rev_a; ..\..\..\..\..\src\mw; ..\..\..\..\..\src\system\rev_a
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration rev_b (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_b
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\common\hdr; ..\..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\..\common\src\drivers; ..\..\..\..\..\..\common\src\mw; ..\..\..\..\..\hdr\rev_b; ..\..\..\..\..\hdr\rev_b\ip; ..\..\..\..\..\hdr\rev_b\mcureg; ..\..\..\..\..\src; ..\..\..\..\..\src\drivers; ..\..\..\..\..\src\interrupts\rev_b; ..\..\..\..\..\src\mw; ..\..\..\..\..\src\system\rev_b
configuration rev_c (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_c; CY_216TEQFP_EVK_rev_a
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\common\hdr; ..\..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\..\common\src\drivers; ..\..\..\..\..\..\common\src\mw; ..\..\..\..\..\hdr\rev_c; ..\..\..\..\..\hdr\rev_c\ip; ..\..\..\..\..\hdr\rev_c\mcureg; ..\..\..\..\..\src; ..\..\..\..\..\src\drivers; ..\..\..\..\..\src\interrupts\rev_c; ..\..\..\..\..\src\mw; ..\..\..\..\..\src\system\rev_c
configuration lite_kit (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLBBHS; CY_USE_PSVP=0; CY_MCU_rev_c; CY_272BGA_EVKLITE_rev_a
  ICCARM.CCIncludePath2: as above
  group adc
    ../../../../../../common/src/drivers/adc/: cy_adc.c cy_adc.h
  group audioss
    ../../../../../src/drivers/audioss/dac/: cy_dac.c cy_dac.h
    ../../../../../src/drivers/audioss/mixer/: cy_mixer.c cy_mixer.h
    ../../../../../src/drivers/audioss/pwm/: cy_pwm.c cy_pwm.h
    ../../../../../src/drivers/audioss/sg/: cy_sg.c cy_sg.h
    ../../../../../src/drivers/audioss/tdm/: cy_tdm.c cy_tdm.h
  group canfd
    ../../../../../../common/src/drivers/canfd/: cy_canfd.c cy_canfd.h
  group cpu
    ../../../../../src/drivers/cpu/: cy_cpu.c cy_cpu.h
  group crypto
    ../../../../../../common/src/drivers/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group cxpi
    ../../../../../../common/src/drivers/cxpi/: cy_cxpi.c cy_cxpi.h
  group dma
    ../../../../../../common/src/drivers/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group ethernet
    ../../../../../src/drivers/ethernet/: cdn_errno.h cdn_stdint.h cedi.h cps_v2.h cy_ethif.c cy_ethif.h cy_ethif_defines.h edd.c edd_int.h edd_rx.c edd_tx.c emac_regs.h emac_regs_macro.h log.h
  group evtgen
    ../../../../../../common/src/drivers/evtgen/: cy_evtgen.c cy_evtgen.h
  group flash
    ../../../../../../common/src/drivers/flash/: cy_flash.c cy_flash.h
  group fpdlink
    ../../../../../src/drivers/fpdlink/: cy_fpdlink.c cy_fpdlink.h
  group gpio
    ../../../../../../common/src/drivers/gpio/: cy_gpio.c cy_gpio.h
  group ipc
    ../../../../../../common/src/drivers/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group lin
    ../../../../../../common/src/drivers/lin/: cy_lin.c cy_lin.h
  group lvd
    ../../../../../../common/src/drivers/lvd/: cy_lvd.c cy_lvd.h
  group mcwdt
    ../../../../../../common/src/drivers/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group mipicsi2
    ../../../../../src/drivers/mipicsi2/: cy_mipicsi2.c cy_mipicsi2.h
  group mpu
    ../../../../../../common/src/drivers/mpu/: cy_mpu.c cy_mpu.h
  group prot
    ../../../../../../common/src/drivers/prot/: cy_prot.c cy_prot.h
  group scb
    ../../../../../../common/src/drivers/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group smartio
    ../../../../../../common/src/drivers/smartio/: cy_smartio.c cy_smartio.h
  group smif
    ../../../../../../common/src/drivers/smif/common/: cy_smif.c cy_smif.h cy_smif_memslot.c cy_smif_memslot.h
  group smif/ver3_1
    ../../../../../../common/src/drivers/smif/ver3_1/: cy_smif_ver_specific.c cy_smif_ver_specific.h
  group srom
    ../../../../../../common/src/drivers/srom/: cy_srom.c cy_srom.h
  group sysclk
    ../../../../../src/drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group sysflt
    ../../../../../../common/src/drivers/sysflt/: cy_sysflt.c cy_sysflt.h
  group sysint
    ../../../../../../common/src/drivers/sysint/: cy_sysint.c cy_sysint.h
  group syslib
    ../../../../../../common/src/drivers/syslib/: cy_syslib.c cy_syslib.h
    ../../../../../../common/src/drivers/syslib/iar/: cy_syslib_iar.s
  group syspm
    ../../../../../../common/src/drivers/syspm/: cy_syspm.c cy_syspm.h
  group syspmic
    ../../../../../src/drivers/syspmic/: cy_syspmic.c cy_syspmic.h
  group sysreset
    ../../../../../../common/src/drivers/sysreset/: cy_sysreset.c cy_sysreset.h
  group sysrtc
    ../../../../../../common/src/drivers/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group systick
    ../../../../../../common/src/drivers/systick/: cy_systick.c cy_systick.h
  group syswdt
    ../../../../../../common/src/drivers/syswdt/: cy_syswdt.c cy_syswdt.h
  group tcpwm
    ../../../../../../common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group trigmux
    ../../../../../../common/src/drivers/trigmux/: cy_trigmux.c cy_trigmux.h
