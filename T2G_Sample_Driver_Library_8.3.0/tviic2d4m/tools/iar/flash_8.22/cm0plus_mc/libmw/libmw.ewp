# IAR project libmw.ewp, settings and files
configuration rev_a (ARM, debug)
  General.OGChipSelectEditMenu: CYT3DL_M0+ Infineon CYT3DL_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_a
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\common\hdr; ..\..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\..\common\src\drivers; ..\..\..\..\..\..\common\src\mw; ..\..\..\..\..\hdr\rev_a; ..\..\..\..\..\hdr\rev_a\ip; ..\..\..\..\..\hdr\rev_a\mcureg; ..\..\..\..\..\src; ..\..\..\..\..\src\drivers; ..\..\..\..\..\src\interrupts\rev_a; ..\..\..\..\..\src\mw; ..\..\..\..\..\src\system\rev_a
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration rev_b (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_b
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\common\hdr; ..\..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\..\common\src\drivers; ..\..\..\..\..\..\common\src\mw; ..\..\..\..\..\hdr\rev_b; ..\..\..\..\..\hdr\rev_b\ip; ..\..\..\..\..\hdr\rev_b\mcureg; ..\..\..\..\..\src; ..\..\..\..\..\src\drivers; ..\..\..\..\..\src\interrupts\rev_b; ..\..\..\..\..\src\mw; ..\..\..\..\..\src\system\rev_b
configuration rev_c (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLABHS; CY_USE_PSVP=0; CY_MCU_rev_c; CY_216TEQFP_EVK_rev_a
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\common\hdr; ..\..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\..\common\src\drivers; ..\..\..\..\..\..\common\src\mw; ..\..\..\..\..\hdr\rev_c; ..\..\..\..\..\hdr\rev_c\ip; ..\..\..\..\..\hdr\rev_c\mcureg; ..\..\..\..\..\src; ..\..\..\..\..\src\drivers; ..\..\..\..\..\src\interrupts\rev_c; ..\..\..\..\..\src\mw; ..\..\..\..\..\src\system\rev_c
configuration lite_kit (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d4m; CYT3DLBBHS; CY_USE_PSVP=0; CY_MCU_rev_c; CY_272BGA_EVKLITE_rev_a
  ICCARM.CCIncludePath2: as above
  group button
    ../../../../../../common/src/mw/button/: cy_button.c cy_button.h
  group flash
    ../../../../../../common/src/mw/flash/: cy_mw_flash.c cy_mw_flash.h
  group gfx_env
    ../../../../../src/mw/gfx_env/: cy_gfx_env.c cy_gfx_env.h
  group mipi_sensor
    ../../../../../src/mw/mipi_sensor/: cy_mipi_sensor.c cy_mipi_sensor.h cy_ov5640_config.h
  group power
    ../../../../../src/mw/power/: cy_power.c cy_power.h
  group semihosting
    ../../../../../../common/src/mw/semihosting/: cy_semihosting.c cy_semihosting.h
  group smif_mem
    ../../../../../src/mw/smif_mem/: cy_smif_device_common.c cy_smif_device_common.h cy_smif_hb_flash.c cy_smif_hb_flash.h cy_smif_s25fl.c cy_smif_s25fl.h cy_smif_s25fs.c cy_smif_s25fs.h cy_smif_semp.c cy_smif_semp.h
  group sw_timer
    ../../../../../../common/src/mw/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
